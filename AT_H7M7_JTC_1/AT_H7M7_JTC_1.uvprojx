# Keil uVision project AT_H7M7_JTC_1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32H745ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: AT_H7M7_JTC_1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\AT_H7M7_JTC_1.sct
  group Source Group 1
    ./: Can.c Can.h Control.c Control.h main.c Joints.c Joints.h RNEA.c RNEA.h Gripper.c Gripper.h MB_RTU_Slave.c MB_RTU_Slave.h TrajGen.c TrajGen.h InputsOutputs.c InputsOutputs.h Debug.c Debug.h MatlabSim.c MatlabSim.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.9.0
